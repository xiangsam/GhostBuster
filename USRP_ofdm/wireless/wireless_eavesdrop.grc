options:
  parameters:
    description: wireless
    generate_options: qt_gui
    id: eavesdrop
    output_language: python
    title: eavesdrop
  states: {}

blocks:
- name: band_width
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 5.08e9
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: ([-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26],)
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: |-
      一帧数据长度96
      字节,共96*8比特
    value: '96'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    comment: 同步字preamble 1
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    comment: 同步字preamble 2
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1e5'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: /home/samrito/workarea/OFDM0516/test_gain/afterChannelAB
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/samrito/workarea/OFDM0516/test_gain/afterChannelAA
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/samrito/workarea/OFDM0516/test_gain/afterChannelAC
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/samrito/workarea/OFDM0516/test_gain/QCA6174
    type: complex
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: qtgui_sink_x_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: band_width
    fc: freq
    fftsize: '1024'
    name: '"A"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: band_width
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_1_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"A"'
    plotwaterfall: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: band_width
    fc: freq
    fftsize: '1024'
    name: '"B"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: band_width
    fc: freq
    fftsize: '1024'
    name: '"B"'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: band_width
    center_freq0: freq
    dev_addr: '"serial = 171825"'
    gain0: '50'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: band_width
    center_freq0: freq
    dev_addr: '"serial = 172006"'
    gain0: '40'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: band_width
    center_freq0: freq
    dev_addr: '"serial = 172006"'
    gain0: '50'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: band_width
    bw1: band_width
    center_freq0: freq
    center_freq1: freq
    dc_offs_enb0: auto
    dc_offs_enb1: auto
    dev_addr: '"serial = 31FBCB0"'
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: band_width
    center_freq0: freq
    dc_offs_enb0: auto
    dev_addr: '"serial = 31FBCB0"'
    gain0: '40'
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_2
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: band_width
    center_freq0: freq
    dev_addr: '"serial = 172006"'
    gain0: '70'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_2_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: band_width
    center_freq0: freq
    dev_addr: '"serial = 171825"'
    gain0: '40'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0_1, '0']
- [analog_const_source_x_1, '0', uhd_usrp_sink_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_1, '0', uhd_usrp_sink_0_1_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0_0_0, '0']
- [uhd_usrp_source_1_0_0, '0', blocks_file_sink_1_0_0_0, '0']
- [uhd_usrp_source_1_0_0, '0', qtgui_sink_x_0_0_1, '0']
- [uhd_usrp_source_1_0_0, '1', blocks_file_sink_1_0_0, '0']
- [uhd_usrp_source_1_0_0, '1', qtgui_sink_x_0_1_0, '0']
- [uhd_usrp_source_1_0_0_0, '0', blocks_file_sink_1_0_0_1, '0']
- [uhd_usrp_source_1_0_0_0, '0', qtgui_sink_x_0_0_1_1, '0']
- [uhd_usrp_source_2, '0', qtgui_sink_x_0_0_1_0, '0']
- [uhd_usrp_source_2_0, '0', blocks_file_sink_1_0_0_0_1, '0']

metadata:
  file_format: 1
